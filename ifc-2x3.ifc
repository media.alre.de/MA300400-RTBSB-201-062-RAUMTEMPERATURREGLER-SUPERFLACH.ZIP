Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturregler, Aufputz superflach, 5…30 °C, 230 VAC, 2(1)A, Öffner, ECO-Funktion, Anzeige Heizen, Schalter EIN/AUS, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA300400, Raumtemperaturregler, Aufputz superflach, 5…30 °C, 230 VAC, 2(1)A, Öffner, ECO-Funktion, Anzeige Heizen, Schalter EIN/AUS
In: Raum
Description: Elektromechanischer Raumtemperaturregler im superflachen Aufputzgehäuse (nur 13,9 mm tief) zur Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels. Durch die thermische Rückführung wird eine sehr genaue Schaltdifferenz erreicht. Mit der unter dem Einstellknopf befindlichen Bereichseinengung kann der Einstellbereich verändert werden. Das Gerät wird mittels Aufputz-/Wandmontage (4-Loch-Befestigung auf UP-Dose) montiert. Geeignet für Warmwasserheizungen. Das Gerät verfügt über eine Anzeige Heizen und einen Schalter EIN/AUS. Bei Beschaltung des Eingangs ECO mit 230 VAC wird auf eine ca. 3 K geringere Temperatur geregelt (Nachtabsenkung).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA300400; ModelLabel: RTBSB-201.062; GlobalTradeItemNumber: 4050528050007; ProductURL: https://alre.de/produkt_MA300400
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.048
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78; Höhe: 78.5; Tiefe: 13.9; RAL-Nummer: 9010; Anschluss: drei-/vieradrig; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Öffner (NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 2; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA300400.pdf
